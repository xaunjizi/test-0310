# Keil uVision project WDT.uvproj, settings and files
target Target 1 (MCS-51)
  device: CBM72XX CHIPSBANK
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(12000000)
  output: LED
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group Source Group 1
    ./: START_CB72.A51
  group src
    ./src/: main.c sysinit.c sysinit.h EXT.c EXT.h isr.c isr.h include.h timer1.c timer1.h uart1.c uart1.h wdt.c wdt.h
